# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HardWare;.\User;.\Library;.\Library
  group User
    ./User/: main.c Deal.c Deal.h
  group HardWare
    ./HardWare/: DHT11.c DHT11.h DS18B20.c DS18B20.h oled.c EEPROM.c EEPROM.h I2C.c I2C.h
  group Library
    ./Library/: UART.c UART.h STC12_DELAY.c STC12_DELAY.h
