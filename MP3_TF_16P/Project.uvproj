# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HardWare;.\User;.\Library;.\Library
  group User
    ./User/: main.c
  group HardWare
    ./HardWare/: MP3_TF_16P.c MP3_TF_16P.h LD3320.c LD3320.h
  group Library
    ./Library/: UART.c UART.h STC12_DELAY.c STC12_DELAY.h
